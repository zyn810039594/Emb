# Keil uVision project templete.uvprojx, settings and files
target ControlSide (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\core;.\lib;.\sys\usart;.\sys\PWM;.\sys\SysTick;.\sys\TimBase;.\sys\iwdg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ./lib/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ./core/: core_cm3.c system_stm32f10x.c
    ./core/startup/: startup_stm32f10x_hd.s
  group user
    ./user/: main.c stm32f10x_it.c SendString.c
  group sys
    ./sys/usart/: bsp_usart.c
    ./sys/PWM/: bsp_GeneralTim.c
    ./sys/SysTick/: bsp_SysTick.c
    ./sys/TimBase/: bsp_TiMbase.c
    ./sys/iwdg/: bsp_iwdg.c
